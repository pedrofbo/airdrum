WARN_QA:remove = "host-user-contaminated"
ERROR_QA:remove = "host-user-contaminated"
TARGET_CFLAGS += "-DSIZEOF_WCHAR_T=2"